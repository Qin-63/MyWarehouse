# Keil uVision project 八路抢答器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 八路抢答器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HEADWARE\KEY;.\HEADWARE\MAIN;.\HEADWARE\SEG;.\HEADWARE\TIM;.\System\DELAY
  group User
    ./: main.c STARTUP.A51
  group System
    ./System/DELAY/: delay.c
  group HARDWARE
    ./HEADWARE/KEY/: key.c
    ./HEADWARE/SEG/: seg.c
    ./HEADWARE/TIM/: tim.c
