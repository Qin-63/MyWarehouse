# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\time;.\APP\motor;.\APP\control;.\APP\pid;.\APP\ANO;.\APP\time6;.\APP\encoder;.\APP\motion;.\APP\exti;.\APP\pwm;.\APP\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/motor/: motor.c
    ./APP/control/: control.c
    ./APP/pid/: pid.c
    ./APP/ANO/: ano.c
    ./APP/time6/: time6.c
    ./APP/encoder/: encoder.c
    ./APP/motion/: motion.c
    ./APP/exti/: exti.c
    ./APP/pwm/: pwm.c
    ./APP/key/: key.c
  group Public
    ./Public/: system.c SysTick.c usart.c
